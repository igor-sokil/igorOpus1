# IAR project device_2_v_14_0_5_0.ewp, settings and files
configuration Flash-Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205ZG ST STM32F205ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_TIME_USES_64; USE_STDPERIPH_DRIVER; STM32F2XX; USE_USB_OTG_FS; KEYBOARD_VER_2_1
  ICCARM.CCIncludePath2: ..\..\wf\inc; ..\..\wf\inc\a.00.c.d; ..\..\wf\usb; ..\..\wf\src\modbusroutine\inc; ..\..\cpp\lib\include\opendnp3\app; ..\..\cpp\lib\include\opendnp3\app\parsing; ..\..\cpp\lib\include\opendnp3\channel; ..\..\cpp\lib\include\opendnp3\decoder; ..\..\cpp\lib\include\opendnp3\gen; ..\..\cpp\lib\include\opendnp3\link; ..\..\cpp\lib\include\opendnp3\master; ..\..\cpp\lib\include\opendnp3\outstation; ..\..\cpp\lib\include\opendnp3\util; ..\..\cpp\lib\include\opendnp3\link; ..\..\cpp\lib\src; ..\..\cpp\lib\src\app; ..\..\cpp\lib\src\app\parsing; ..\..\cpp\lib\src\link; ..\..\cpp\lib\src\util; ..\..\cpp\lib\src\outstation; ..\..\cpp\lib\src\outstation\event; ..\..\cpp\lib\src\gen; ..\..\cpp\lib\src\gen\objects; ..\..\qtsrc; ..\..\ser4cpp\container; ..\..\ser4cpp\serialization; ..\..\ser4cpp\util; ..\..\lib\CMSIS\Device\ST\STM32F2xx\Include; ..\..\lib\STM32F2xx_StdPeriph_Driver\inc; ..\..\lib\STM32_USB_OTG_Driver\inc; ..\..\lib\STM32_USB_Device_Library\Core\inc; ..\..\lib\STM32_USB_Device_Library\Class\cdc\inc; ..\..\mw\FatFs\inc; ..\..\svw\Config; ..\..\svw\OS; ..\..\svw\SEGGER
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: device_2_v_14_0_5_0.bin
  ILINK.IlinkOutputFile: device_2_v_14_0_4_0.out
  ILINK.IlinkIcfFile: ..\without iec61850\stm32f2xx_flash.icf
  ILINK.IlinkExtraOptions: --timezone_lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS/inc
    ../../lib/CMSIS/Device/ST/STM32F2xx/Include/: stm32f2xx.h system_stm32f2xx.h
  group CMSIS/src
    ../../lib/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group cpp/lib/include/opendnp3/app
    ../../cpp/lib/include/opendnp3/app/: BaseMeasurementTypes.cpp DNPTime.cpp Flags.cpp GroupVariationID.cpp Indexed.cpp OctetString.cpp
  group cpp/lib/include/opendnp3/app/parsing
    ../../cpp/lib/include/opendnp3/app/parsing/: ICollection_for_Group50Var1.cpp ICollection_for_Group50Var3.cpp ICollection_for_uint16.cpp ICollection_Indexed_for_AnalogOutputDouble64.cpp ICollection_Indexed_for_AnalogOutputFloat32.cpp ICollection_Indexed_for_AnalogOutputInt16.cpp ICollection_Indexed_for_AnalogOutputInt32.cpp ICollection_Indexed_for_ControlRelayOutputBlock.cpp ICollection_Indexed_for_IINValue.cpp ICollection_Indexed_for_TimeAndInterval.cpp
  group cpp/lib/include/opendnp3/master
    ../../cpp/lib/include/opendnp3/master/: CommandPointResult.cpp HeaderInfo.cpp
  group cpp/lib/include/opendnp3/util
    ../../cpp/lib/include/opendnp3/util/: Buffer.cpp
  group cpp/lib/src/app
    ../../cpp/lib/src/app/: AnalogCommandEvent.cpp AnalogOutput.cpp APDUHeader.cpp APDURequest.cpp APDUResponse.cpp APDUWrapper.cpp AppControlField.cpp BinaryCommandEvent.cpp BitfieldRangeWriteIterator_for_uint8.cpp ClassField.cpp ControlRelayOutputBlock.cpp CountWriteIterator_for_Analog.cpp CountWriteIterator_for_AnalogOutputStatus.cpp CountWriteIterator_for_Binary.cpp CountWriteIterator_for_BinaryOutputStatus.cpp CountWriteIterator_for_ControlRelayOutputBlock.cpp CountWriteIterator_for_DoubleBitBinary.cpp DNP3Serializer.cpp DownSampling.cpp EventTriggers.cpp Functions.cpp GroupVariationRecord.cpp HeaderWriter.cpp HeaderWriter_for_Analog.cpp HeaderWriter_for_AnalogOutputStatus.cpp HeaderWriter_for_Binary.cpp HeaderWriter_for_BinaryOutputStatus.cpp HeaderWriter_for_DoubleBitBinary.cpp IINField.cpp MeasurementFactory.cpp MeasurementInfo.cpp MeasurementTypes.cpp MeasurementTypeSpecs.cpp OctetData.cpp PrefixedWriteIterator_for_Analog.cpp PrefixedWriteIterator_for_AnalogOutputStatus.cpp PrefixedWriteIterator_for_Binary.cpp PrefixedWriteIterator_for_BinaryOutputStatus.cpp PrefixedWriteIterator_for_Counter.cpp PrefixedWriteIterator_for_DoubleBitBinary.cpp PrefixedWriteIterator_for_FrozenCounter.cpp PrefixedWriteIterator_for_OctetString.cpp QualityFlags.cpp range.cpp RangeWriteIterator_for_Binary.cpp RangeWriteIterator_for_BinaryOutputStatus.cpp RangeWriteIterator_for_Counter.cpp RangeWriteIterator_for_DoubleBitBinary.cpp RangeWriteIterator_for_FrozenCounter.cpp RangeWriteIterator_for_OctetString.cpp Serializer.cpp
  group cpp/lib/src/app/parsing
    ../../cpp/lib/src/app/parsing/: APDUHeaderParser.cpp ParseResult.cpp
  group cpp/lib/src/gen
    ../../cpp/lib/src/gen/: Attributes.cpp CommandStatus.cpp DoubleBit.cpp FunctionCode.cpp IntervalUnits.cpp LinkFunction.cpp
  group cpp/lib/src/gen/objects
    ../../cpp/lib/src/gen/objects/: Group1.cpp Group11.cpp Group12.cpp Group2.cpp Group20.cpp Group22.cpp Group30.cpp Group32.cpp Group4.cpp Group50.cpp Group51.cpp Group60.cpp
  group cpp/lib/src/link
    ../../cpp/lib/src/link/: Addresses.cpp CRC.cpp LinkFrame.cpp LinkHeader.cpp
  group cpp/lib/src/outstation
    ../../cpp/lib/src/outstation/: ApplicationIIN.cpp AssignClassHandler.cpp ClassBasedRequestHandler.cpp CommandActionAdapter.cpp ControlState.cpp DeferredRequest.cpp Event.cpp EventBufferConfig.cpp IClassAssigner.cpp ICommandAction.cpp IEventReceiver.cpp IEventSelector.cpp IINHelpers.cpp IResponseLoader.cpp IStaticSelector.cpp NumRetries.cpp OctetStringSerializer.cpp ParsedRequest.cpp ReadHandler.cpp ResponseContext.cpp SimpleCommandHandler.cpp StaticDataCell.cpp TimeSyncState.cpp
  group cpp/lib/src/outstation/event
    ../../cpp/lib/src/outstation/event/: ASDUEventWriteHandler.cpp ClazzCount.cpp EventBuffer.cpp EventCollection.cpp EventLists.cpp EventRecord.cpp EventSelection.cpp EventStorage.cpp EventTypeImpl.cpp EventUpdate.cpp EventWriters_for_Analog.cpp EventWriters_for_AnalogOutputStatus.cpp EventWriters_for_Binary.cpp EventWriters_for_Counter.cpp EventWriting.cpp IEventType.cpp IEventWriteHandler.cpp List_for_EventRecord_part1.cpp List_for_EventRecord_part2.cpp List_TypedEventRecord_for_AnalogSpec_part1.cpp List_TypedEventRecord_for_AnalogSpec_part2.cpp List_TypedEventRecord_for_BinaryOutputStatusSpec_part2.cpp List_TypedEventRecord_for_BinarySpec_part1.cpp List_TypedEventRecord_for_FrozenCounterSpec_part1.cpp List_TypedEventRecord_for_FrozenCounterSpec_part2.cpp List_TypedEventRecord_for_OctetStringSpec_part1.cpp List_TypedEventRecord_for_OctetStringSpec_part2.cpp Nodes.cpp TypedEventRecord.cpp TypedStorage.cpp
  group cpp/lib/src/util
    ../../cpp/lib/src/util/: TimeDuration.cpp Timestamp.cpp
  group exe4cpp
    ../../exe4cpp/: IExecutorExe4cpp.cpp ISteadyTimeSourceExe4cpp.cpp TimerExe4cpp.cpp
  group FatFs/inc
    ../../mw/FatFs/inc/: diskio.h fatfs.h ff.h ff_gen_drv.h ffconf.h ffconf_template.h integer.h user_diskio.h
  group FatFs/src
    ../../mw/FatFs/src/: diskio.c fatfs.c ff.c ff_gen_drv.c user_diskio.c
  group lib/runtime
    ../../wf/lib/runtime/: stack_protection.c
  group lib/time
    ../../wf/time/: clock.c getzone.c time.c time64.c
  group Linker
    ../: stm32f2xx_flash_extsram.icf stm32f2xx_sram.icf
  group Linker/without iec61850
    ../without iec61850/: StackDepth.suc stm32f2xx_flash.icf
  group ser4cpp/container
    ../../ser4cpp/container/: Array__for__Node_for_EventRecord.cpp Array__for__Node_TypedEventRecord_for_AnalogOutputStatusSpec.cpp Array__for__Node_TypedEventRecord_for_AnalogSpec.cpp Array__for__Node_TypedEventRecord_for_BinaryOutputStatusSpec.cpp Array__for__Node_TypedEventRecord_for_BinarySpec.cpp Array__for__Node_TypedEventRecord_for_CounterSpec.cpp Array__for__Node_TypedEventRecord_for_DoubleBitBinarySpec.cpp Array__for__Node_TypedEventRecord_for_FrozenCounterSpec.cpp Array__for__Node_TypedEventRecord_for_OctetStringSpec.cpp ArrayView__for__Node_for_EventRecord.cpp ArrayView__for__Node_TypedEventRecord_for_AnalogOutputStatusSpec.cpp ArrayView__for__Node_TypedEventRecord_for_AnalogSpec.cpp ArrayView__for__Node_TypedEventRecord_for_BinaryOutputStatusSpec.cpp BufferSer4.cpp HasLength.cpp RSeq.cpp StaticBuffer.cpp WSeq.cpp
  group ser4cpp/serialization
    ../../ser4cpp/serialization/: SerializationTemplates.cpp
  group ser4cpp/util
    ../../ser4cpp/util/: Comparisons.cpp
  group Startup
    ../../lib/CMSIS/Device/ST/STM32F2xx/Source/Templates/iar/: startup_stm32f2xx.s
  group STM_Periph_Driver/inc
    ../../lib/STM32F2xx_StdPeriph_Driver/inc/: misc.h stm32f2xx_dbgmcu.h stm32f2xx_dma.h stm32f2xx_exti.h stm32f2xx_gpio.h stm32f2xx_i2c.h stm32f2xx_rcc.h stm32f2xx_spi.h stm32f2xx_syscfg.h stm32f2xx_tim.h stm32f2xx_usart.h
  group STM_Periph_Driver/src
    ../../lib/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_dbgmcu.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c
  group svw/Config
    ../../svw/Config/: Global.h SEGGER_RTT_Conf.h SEGGER_SYSVIEW_Conf.h SEGGER_SYSVIEW_Config_NoOS.c
  group svw/SEGGER
    ../../svw/SEGGER/: SEGGER.h SEGGER_RTT.c SEGGER_RTT.h SEGGER_SYSVIEW.c SEGGER_SYSVIEW.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER_SYSVIEW_Int.h
  group USB Device/Class/CDC/inc
    ../../lib/STM32_USB_Device_Library/Class/cdc/inc/: usbd_cdc_core.h
  group USB Device/Library/inc
    ../../lib/STM32_USB_Device_Library/Core/inc/: usbd_core.h usbd_def.h usbd_ioreq.h usbd_req.h usbd_usr.h
  group USB Device/Library/src
    ../../lib/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB Driver/inc
    ../../lib/STM32_USB_OTG_Driver/inc/: usb_bsp.h usb_core.h usb_dcd.h usb_dcd_int.h usb_defines.h usb_regs.h
  group USB Driver/src
    ../../lib/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group user/inc/EEPROM
    ../../wf/inc/: const_eeprom.h
  group user/inc/FSMC
    ../../wf/inc/: const_fsmc.h
  group user/inc/general
    ../../wf/inc/: const_septoints_interval.h constants.h functions_external.h functions_global.h header.h lib.h macroses.h type_definition.h variables_external.h variables_global.h
  group user/inc/general/a.00.c.d
    ../../wf/inc/a.00.c.d/: const_global.h
  group user/inc/I2C
    ../../wf/inc/: const_i2c.h
  group user/inc/interfaces
    ../../wf/inc/: const_interfaces.h
  group user/inc/Log
    ../../wf/src/log/: cmd_log.h
  group user/inc/menu
    ../../wf/inc/: const_lcd_and_keyboard.h const_menu_achr_chapv.h const_menu_apv.h const_menu_buttons.h const_menu_chose_communication_parameters.h const_menu_chose_data_time_settings.h const_menu_chose_extra_settings.h const_menu_chose_grupa_ustavok.h const_menu_chose_settings.h const_menu_chose_settings_protection.h const_menu_chose_settings_registrators.h const_menu_chose_settings_switcher.h const_menu_chose_settings_uvv.h const_menu_configuration.h const_menu_d_and.h const_menu_d_not.h const_menu_d_or.h const_menu_d_xor.h const_menu_df.h const_menu_dt.h const_menu_extended_logic.h const_menu_general_pickups_el.h const_menu_info.h const_menu_leds.h const_menu_level_password.h const_menu_main.h const_menu_measurement.h const_menu_mtz.h const_menu_mtz04.h const_menu_point_time_settings.h const_menu_registrators.h const_menu_resurs.h const_menu_setting_language.h const_menu_state_inputs_outputs.h const_menu_switch.h const_menu_time.h const_menu_transfer_functions.h const_menu_transformator.h const_menu_tznp.h const_menu_Umax.h const_menu_Umin.h const_menu_UP.h const_menu_urov.h const_menu_vidkluchennja.h const_menu_VMP.h const_menu_zdz.h const_menu_zop.h const_menu_zz.h
  group user/inc/menu/a.00.c.d
    ../../wf/inc/a.00.c.d/: const_menu_outputs.h
  group user/inc/menu/without iec61850
    ../../wf/inc/without iec61850/: const_menu_diagnostyka.h const_menu_inputs.h
  group user/inc/microcontriller
    ../../wf/inc/: hw_config.h platform_config.h stm32f2xx_conf.h stm32f2xx_it.h
  group user/inc/protection
    ../../wf/inc/: const_global_timers.h const_koef_povernennja.h const_measurement.h const_watchdog.h
  group user/inc/Serial Dataflash
    ../../wf/inc/: const_driver_serial_dataflash.h
  group user/src/EEPROM
    ../../wf/src/: eeprom.c
  group user/src/FSMC
    ../../wf/src/: fsmc_sram.c
  group user/src/general
    ../../wf/src/: main.c procedures.c start_settings.c
  group user/src/I2C
    ../../wf/src/: i2c.c
  group user/src/interfaces
    ../../wf/src/: interfaces.c modbus.c
  group user/src/interfaces/component
    ../../wf/src/modbusroutine/component/: YustBigComponent.c
  group user/src/interfaces/inc
    ../../wf/src/modbusroutine/inc/: componentdef.h componentenum.h prototyps.h variables_external_m.h variables_global_m.h
  group user/src/interfaces/modbusroutine
    ../../wf/src/modbusroutine/: procedures_guest.c procedures_m.c start_settings_m.c supervisor.c uprFunc000for2021.c ustFunc000for2021.c
  group user/src/interrupts
    ../../wf/src/: interrupts.c
  group user/src/menu
    ../../wf/src/: driver_lcd.c menu.c menu_achr_chapv.c menu_apv.c menu_chose_communication_parameters.c menu_chose_extra_settings .c menu_chose_grupa_ustavok.c menu_chose_settings.c menu_chose_settings_protection.c menu_chose_settings_uvv.c menu_view_measurement.c menu_VMP.c menu_zdz.c menu_zop.c menu_zz.c
  group user/src/microcontroller
    ../../wf/src/: hw_config.c
  group user/src/protection
    ../../wf/src/: ar_routines.c measurement.c
  group user/src/Serial Dataflash
    ../../wf/src/: driver_serial_dataflash.c
  group user/usb/inc
    ../../wf/usb/: usb_conf.h usbd_cdc_vcp.h usbd_conf.h usbd_desc.h
