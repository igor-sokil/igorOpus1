# IAR project A01v_19_0_0_0.ewp, settings and files
configuration Flash-Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205ZG ST STM32F205ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_TIME_USES_64; USE_STDPERIPH_DRIVER; STM32F2XX; USE_USB_OTG_FS; KEYBOARD_VER_2_1; DEBUG_MODE_23_07_19
  ICCARM.CCIncludePath2: ..\..\wf\inc; ..\..\wf\inc\a.00.c.d; ..\..\wf\usb; ..\..\wf\src\modbusroutine\inc; ..\..\lib\CMSIS\Device\ST\STM32F2xx\Include; ..\..\lib\STM32F2xx_StdPeriph_Driver\inc; ..\..\lib\STM32_USB_OTG_Driver\inc; ..\..\lib\STM32_USB_Device_Library\Core\inc; ..\..\lib\STM32_USB_Device_Library\Class\cdc\inc; ..\..\mw\FatFs\inc; ..\..\svw\Config; ..\..\svw\OS; ..\..\svw\SEGGER
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: A01v_19_0_0_0.srec
  ILINK.IlinkOutputFile: A01v_19_0_0_0.out
  ILINK.IlinkIcfFile: ..\stm32f2xx_flash.icf
  ILINK.IlinkExtraOptions: --timezone_lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS/inc
    ../../lib/CMSIS/Device/ST/STM32F2xx/Include/: stm32f2xx.h system_stm32f2xx.h
  group CMSIS/src
    ../../lib/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group FatFs/inc
    ../../mw/FatFs/inc/: diskio.h fatfs.h ff.h ff_gen_drv.h ffconf.h ffconf_template.h integer.h user_diskio.h
  group FatFs/src
    ../../mw/FatFs/src/: diskio.c fatfs.c ff.c ff_gen_drv.c user_diskio.c
  group lib/runtime
    ../../wf/lib/runtime/: stack_protection.c
  group lib/time
    ../../wf/time/: clock.c getzone.c time.c time64.c
  group Linker
    ../: StackDepth.suc stm32f2xx_flash.icf stm32f2xx_flash_extsram.icf stm32f2xx_sram.icf
  group Startup
    ../../lib/CMSIS/Device/ST/STM32F2xx/Source/Templates/iar/: startup_stm32f2xx.s
  group STM_Periph_Driver/inc
    ../../lib/STM32F2xx_StdPeriph_Driver/inc/: misc.h stm32f2xx_dbgmcu.h stm32f2xx_dma.h stm32f2xx_exti.h stm32f2xx_gpio.h stm32f2xx_i2c.h stm32f2xx_rcc.h stm32f2xx_spi.h stm32f2xx_syscfg.h stm32f2xx_tim.h stm32f2xx_usart.h
  group STM_Periph_Driver/src
    ../../lib/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_dbgmcu.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c
  group SystemView/Config
    ../../svw/Config/: Global.h SEGGER_RTT_Conf.h SEGGER_SYSVIEW_Conf.h SEGGER_SYSVIEW_Config_NoOS.c
  group SystemView/SEGGER
    ../../svw/SEGGER/: SEGGER.h SEGGER_RTT.c SEGGER_RTT.h SEGGER_SYSVIEW.c SEGGER_SYSVIEW.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER_SYSVIEW_Int.h
  group USB Device/Class/CDC/inc
    ../../lib/STM32_USB_Device_Library/Class/cdc/inc/: usbd_cdc_core.h
  group USB Device/Class/CDC/src
    ../../lib/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group USB Device/Library/inc
    ../../lib/STM32_USB_Device_Library/Core/inc/: usbd_core.h usbd_def.h usbd_ioreq.h usbd_req.h usbd_usr.h
  group USB Device/Library/src
    ../../lib/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB Driver/inc
    ../../lib/STM32_USB_OTG_Driver/inc/: usb_bsp.h usb_core.h usb_dcd.h usb_dcd_int.h usb_defines.h usb_regs.h
  group USB Driver/src
    ../../lib/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group user/inc/EEPROM
    ../../wf/inc/: const_eeprom.h
  group user/inc/FSMC
    ../../wf/inc/: const_fsmc.h
  group user/inc/general
    ../../wf/inc/: const_global_total.h const_septoints_interval.h constants.h functions_external.h functions_global.h header.h lib.h macroses.h type_definition.h variables_external.h variables_global.h
  group user/inc/general/a.00.c.d
    ../../wf/inc/a.00.c.d/: const_global.h
  group user/inc/I2C
    ../../wf/inc/: const_i2c.h
  group user/inc/interfaces
    ../../wf/inc/: const_interfaces.h
  group user/inc/menu
    ../../wf/inc/: const_lcd_and_keyboard.h const_menu_achr_chapv.h const_menu_apv.h const_menu_buttons.h const_menu_chose_communication_parameters.h const_menu_chose_data_time_settings.h const_menu_chose_extra_settings.h const_menu_chose_grupa_ustavok.h const_menu_chose_settings.h const_menu_chose_settings_protection.h const_menu_chose_settings_registrators.h const_menu_chose_settings_switcher.h const_menu_chose_settings_uvv.h const_menu_configuration.h const_menu_d_and.h const_menu_d_not.h const_menu_d_or.h const_menu_d_xor.h const_menu_df.h const_menu_diagnostyka.h const_menu_dt.h const_menu_dz.h const_menu_dzo.h const_menu_extended_logic.h const_menu_general_pickups_el.h const_menu_info.h const_menu_inputs.h const_menu_leds.h const_menu_level_password.h const_menu_main.h const_menu_measurement.h const_menu_mtz.h const_menu_mtzo.h const_menu_mtzr.h const_menu_point_time_settings.h const_menu_registrators.h const_menu_reprogram.h const_menu_resurs.h const_menu_setting_language.h const_menu_state_inputs_outputs.h const_menu_switch.h const_menu_time.h const_menu_transfer_functions.h const_menu_transformator.h const_menu_tznp.h const_menu_Umax.h const_menu_Umin.h const_menu_UP.h const_menu_urov.h const_menu_vidkluchennja.h const_menu_VMP.h const_menu_zdz.h const_menu_zop.h const_menu_zz.h
  group user/inc/menu/a.00.c.d
    ../../wf/inc/a.00.c.d/: const_menu_outputs.h
  group user/inc/microcontriller
    ../../wf/inc/: hw_config.h platform_config.h stm32f2xx_conf.h stm32f2xx_it.h
  group user/inc/protection
    ../../wf/inc/: const_global_timers.h const_koef_povernennja.h const_measurement.h const_watchdog.h
  group user/inc/Serial Dataflash
    ../../wf/inc/: const_driver_serial_dataflash.h
  group user/src/EEPROM
    ../../wf/src/: eeprom.c
  group user/src/FSMC
    ../../wf/src/: fsmc_sram.c
  group user/src/general
    ../../wf/src/: main.c procedures.c start_settings.c
  group user/src/I2C
    ../../wf/src/: i2c.c
  group user/src/interfaces
    ../../wf/src/: interfaces.c modbus.c
  group user/src/interfaces/component
    ../../wf/src/modbusroutine/component/: ACMDSmallComponent.c AISmallComponent.c AISmallComponent_guest.c ANDBigComponent.c DOUTBigComponent.c DOUTSmallComponent.c DTRBigComponent.c DVBigComponent.c DVSmallComponent.c GCMDSmallComponent.c IUSmallComponent.c KEYBigComponent.c MFTBigComponent.c NOTBigComponent.c ORBigComponent.c PFBigComponent.c PKVBigComponent.c PKVBigComponent_guest.c PREGBigComponent.c REGBigComponent.c RPRBigComponent.c RPRSmallComponent.c SDIBigComponent.c SDISmallComponent.c UPRBigComponent.c USTBigComponent.c VVBigComponent.c XORBigComponent.c YustBigComponent.c
  group user/src/interfaces/inc
    ../../wf/src/modbusroutine/inc/: componentdef.h componentenum.h prototyps.h variables_external_m.h variables_global_m.h
  group user/src/interfaces/modbusroutine
    ../../wf/src/modbusroutine/: procedures_guest.c procedures_m.c start_settings_m.c supervisor.c
  group user/src/interrupts
    ../../wf/src/: interrupts.c
  group user/src/menu
    ../../wf/src/: driver_lcd.c menu.c menu_achr_chapv.c menu_apv.c menu_chose_communication_parameters.c menu_chose_extra_settings .c menu_chose_grupa_ustavok.c menu_chose_settings.c menu_chose_settings_protection.c menu_chose_settings_registrators.c menu_chose_settings_uvv.c menu_configuration.c menu_data_time_settings.c menu_df.c menu_diagnostyka.c menu_dt.c menu_dzo.c menu_dzr.c menu_energy.c menu_extended_logic.c menu_general_pickups_el.c menu_info.c menu_inputs_outputs_leds_reg_df_buttons.c menu_level_password.c menu_main.c menu_mtz.c menu_mtzo.c menu_mtzr.c menu_point_time_settings.c menu_registrators.c menu_resurs.c menu_setting_language.c menu_state_inputs_outputs.c menu_switch.c menu_tf.c menu_time.c menu_transformator.c menu_tznp.c menu_Umax.c menu_Umin.c menu_UP.c menu_urov.c menu_vidkluchennja.c menu_view_measurement.c menu_VMP.c menu_zdz.c menu_zop.c menu_zz.c
  group user/src/microcontroller
    ../../wf/src/: hw_config.c stm32f2xx_it.c
  group user/src/protection
    ../../wf/src/: ar_routines.c measurement.c protections.c
  group user/src/Serial Dataflash
    ../../wf/src/: driver_serial_dataflash.c
  group user/usb/inc
    ../../wf/usb/: usb_conf.h usbd_cdc_vcp.h usbd_conf.h usbd_desc.h
  group user/usb/src
    ../../wf/usb/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
