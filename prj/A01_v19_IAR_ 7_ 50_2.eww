<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\v_19_00\A01_v_19_0_0_0_IAR_7_50_2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\v_19_00\A01_v_19_1_0_0_IAR_7_50_2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\v_19_00\A01_v_19_2_0_0_IAR_7_50_2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\v_19_00\A01_v_19_3_0_0_IAR_7_50_2.ewp</path>
  </project>
  <batchBuild/>
</workspace>


